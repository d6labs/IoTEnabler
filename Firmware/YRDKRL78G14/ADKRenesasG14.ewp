# IAR project ADKRenesasG14.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: USE_SPI
  ICCRL78.CCIncludePath2: $PROJ_DIR$; ..; drv; ..\GSHAL\; applilet3_src\; ..\Apps\; ..\Micrium\Software\Cfg; ..\Micrium\Software\uC-LIB; ..\Micrium\Software\uC-CPU; ..\Micrium\Software\uC-CPU\RL78\IAR; ..\Micrium\Software\uC-Probe\Target\Communication\Generic\Source; ..\Micrium\Software\uC-Probe\Target\Communication\Generic\OS\None; ..\Micrium\Software\uC-Probe\Target\Communication\Generic\WiFi\Source; ..\Micrium\Software\uC-Probe\Target\Communication\Generic\WiFi\OS\None
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkr5f104pj.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group Apps
    ../Apps/: App_Exosite.c App_PassThroughSPI.c App_ProbeDemo.c App_ProgramMode.c App_Startup.c App_Swarm.c App_Swarm.h App_WhiskerGW.c Apps.h mqtt.c xr20m1170.c
  group ATCmdLib
    ../ATCmdLib/: AtCmdLib.c AtCmdLib.h
  group GSHAL
    ../GSHAL/: GainSpan_SPI.c GainSpan_SPI.h GSHAL.c mstimer.c mstimer.h NVSettings.c NVSettings.h
  group jsmn
    ../jsmn/: jsmn.c jsmn.h
  group Micrium/Software/Cfg
    ../Micrium/Software/Cfg/: app_cfg.h cpu_cfg.h includes.h probe_com_cfg.h
  group Micrium/Software/uC/CPU
    ../Micrium/Software/uC-CPU/: cpu_bsp.c cpu_core.c cpu_core.h cpu_def.h
  group Micrium/Software/uC/CPU/RL78/IAR
    ../Micrium/Software/uC-CPU/RL78/IAR/: cpu.h
  group Micrium/Software/uC/LIB
    ../Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/Software/uC/Probe/Target/Communication/Generic/OS/None
    ../Micrium/Software/uC-Probe/Target/Communication/Generic/OS/None/: probe_com_os.c
  group Micrium/Software/uC/Probe/Target/Communication/Generic/Source
    ../Micrium/Software/uC-Probe/Target/Communication/Generic/Source/: probe_com.c probe_com.h
  group Micrium/Software/uC/Probe/Target/Communication/Generic/WiFi/OS/None
    ../Micrium/Software/uC-Probe/Target/Communication/Generic/WiFi/OS/None/: probe_wifi_os.c
  group Micrium/Software/uC/Probe/Target/Communication/Generic/WiFi/Source
    ../Micrium/Software/uC-Probe/Target/Communication/Generic/WiFi/Source/: probe_wifi.c probe_wifi.h
  group sensors
    ../sensors/: Accelerometer.c Accelerometer.h LightSensor.c LightSensor.h Potentiometer.c Potentiometer.h Temperature.c Temperature.h
  group YRDKRL78G14/applilet3_src
    applilet3_src/: r_cg_serial.c r_cg_serial.h r_cg_serial_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c
  group YRDKRL78G14/drv
    drv/: ADC.c ADC.h I2C.c I2C.h led.c led.h RDKRL78_spi.c RDKRL78_spi.h SAU.h SPI _G14.c SPI.h Timer.c Timer.h UART.c UART.h
  group YRDKRL78G14/drv/EInk
    drv/EInk/: eink_driver.c eink_driver.h eink_rdk_display.c eink_rdk_display.h user_app.c user_app.h
  group YRDKRL78G14/drv/Glyph
    drv/Glyph/: glyph_api.h glyph_cfg.h glyph_register.c glyph_types.h lcd.c lcd.h RL78GlyphLib_Debug.r87
  group YRDKRL78G14/drv/Glyph/Drivers
    drv/Glyph/Drivers/: ST7579_LCD.h
  group YRDKRL78G14/init
    init/: hwsetup.c hwsetup.h
  group YRDKRL78G14/system
    system/: console.c console.h EEPROM.c EEPROM.h GainSpan_IO.c GainSpan_IO.h platform.h Switch.c Switch.h YRDKRL78G14.h
